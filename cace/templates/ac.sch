** sch_path: cace/templates/ac.sch
**.subckt ac
I0 VDD Ibias CACE{ibias}
C1 Vout GND CACE{cl} m=1
V0 VSS GND 0
V2 VDD GND CACE{vdd}
E1 Vp net2 net1 GND 0.5
E2 Vn net2 net1 GND -0.5
Vdm net1 GND ac 1
Vcm net2 GND CACE{vcm}
x1 VDD Ibias Vout Vn Vp VDD VSS ttsky25_two_stage_opamp
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/CACE{lib_file}/sky130.lib.spice CACE{corner}

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




.control


    * run ac simulation
    ac dec 100 1 100Meg

    * measure parameters
    let gain = db(v(Vout)/(v(vp)-v(vn)))
    let av = v(Vout)/(v(vp)-v(vn))
    let phase_margin = phase(av)*180/pi + 180
    meas ac gain_max MAX gain
    meas ac UGF WHEN gain = 0
    meas ac PM find phase_margin when gain = 0

    echo $&gain_max $&ugf $&PM > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
