** sch_path: cace/templates/transient.sch
**.subckt transient
I0 VDD Ibias CACE{ibias}
C1 Vout GND CACE{cl} m=1
V0 VSS GND 0
V2 VDD GND CACE{vdd}
x2 VDD Ibias Vout Vn Vp VDD VSS ttsky25_two_stage_opamp
Evdrv1 Vn GND Vout GND 1
V3 Vp GND DC 0 PWL(0 0 100n 0 100.1n CACE{vdd})
**** begin user architecture code


.control


    * Step function applied at time 100ns, save transient data
    tran 10n CACE{Tmax}
    set wr_singlescale
    wrdata CACE{simpath}/CACE{filename}_CACE{N}.data V(Vout) V(Vp)
.endc




.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/CACE{lib_file}/sky130.lib.spice CACE{corner}

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end
