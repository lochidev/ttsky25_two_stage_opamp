v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
N -490 -670 -490 -610 {lab=Vpo}
N -330 -670 -330 -610 {lab=Vout1}
N -850 -190 -810 -190 {lab=VN}
N -490 -710 -490 -670 {lab=Vpo}
N -330 -710 -330 -670 {lab=Vout1}
N -1220 360 -1220 600 {lab=IBIAS}
N -90 -650 -90 -570 {lab=VOUT}
N -330 -700 -180 -700 {lab=Vout1}
N 140 -610 220 -610 {lab=VOUT}
N 40 -610 140 -610 {lab=VOUT}
N -90 -610 40 -610 {lab=VOUT}
N -1220 600 -1220 640 {lab=IBIAS}
N -90 -670 -90 -650 {lab=VOUT}
N -90 -570 -90 -520 {lab=VOUT}
N -180 -620 -180 -600 {lab=#net1}
N -180 -540 -180 -530 {lab=VOUT}
N -180 -530 -90 -530 {lab=VOUT}
N -180 -700 -180 -690 {lab=Vout1}
N -180 -630 -180 -620 {lab=#net1}
N 490 150 510 150 {lab=VP}
N 510 150 520 150 {lab=VP}
N -240 -660 -200 -660 {lab=VSS}
N -780 1040 -780 1080 {lab=#net2}
N -780 1040 -750 1040 {lab=#net2}
N -750 1040 -720 1040 {lab=#net2}
N -720 1040 -720 1080 {lab=#net2}
N -720 1080 -690 1080 {lab=#net2}
N -630 1080 -600 1080 {lab=IBIAS}
N -600 1040 -600 1080 {lab=IBIAS}
N -600 1040 -570 1040 {lab=IBIAS}
N -570 1040 -540 1040 {lab=IBIAS}
N -540 1040 -540 1080 {lab=IBIAS}
N -490 1040 -490 1080 {lab=Vz}
N -490 1040 -460 1040 {lab=Vz}
N -460 1040 -430 1040 {lab=Vz}
N -430 1040 -430 1080 {lab=Vz}
N -430 1080 -400 1080 {lab=Vz}
N -340 1080 -310 1080 {lab=#net3}
N -310 1040 -310 1080 {lab=#net3}
N -310 1040 -280 1040 {lab=#net3}
N -280 1040 -250 1040 {lab=#net3}
N -250 1040 -250 1080 {lab=#net3}
N -180 1040 -150 1040 {lab=VOUT}
N -150 1040 -150 1080 {lab=VOUT}
N -150 1080 -120 1080 {lab=VOUT}
N 20 1080 50 1080 {lab=VOUT}
N 50 1040 50 1080 {lab=VOUT}
N 50 1040 80 1040 {lab=VOUT}
N 80 1040 110 1040 {lab=VOUT}
N 110 1040 110 1080 {lab=VOUT}
N -660 1010 -280 1010 {lab=EN}
N -280 1010 -90 1010 {lab=EN}
N -90 1010 -90 1040 {lab=EN}
N -370 1010 -370 1040 {lab=EN}
N -20 1430 10 1430 {lab=#net2}
N -750 830 -660 830 {lab=EN}
N -50 1350 30 1350 {lab=#net2}
N 40 1350 40 1390 {lab=#net2}
N 30 1350 40 1350 {lab=#net2}
N -50 1350 -50 1390 {lab=#net2}
N -10 1350 -10 1430 {lab=#net2}
N -50 1390 -10 1390 {lab=#net2}
N -10 1390 40 1390 {lab=#net2}
N -100 1430 -80 1430 {lab=VSS}
N 70 1430 90 1430 {lab=VSS}
N -130 1430 -100 1430 {lab=VSS}
N -210 1430 -190 1430 {lab=#net3}
N -290 1430 -270 1430 {lab=VSS}
N -370 1430 -350 1430 {lab=#net3}
N -450 1430 -430 1430 {lab=VSS}
N -540 1430 -510 1430 {lab=#net3}
N -570 1350 -50 1350 {lab=#net2}
N -160 1350 -160 1390 {lab=#net2}
N -240 1350 -240 1390 {lab=#net2}
N -320 1350 -320 1390 {lab=#net2}
N -400 1350 -400 1390 {lab=#net2}
N -480 1350 -480 1390 {lab=#net2}
N -570 1350 -570 1390 {lab=#net2}
N -570 1390 -160 1390 {lab=#net2}
N -200 1320 -200 1430 {lab=#net3}
N -260 1320 -200 1320 {lab=#net3}
N 90 1430 110 1430 {lab=VSS}
N 170 1430 190 1430 {lab=#net3}
N 250 1430 270 1430 {lab=VSS}
N 330 1430 350 1430 {lab=#net3}
N 410 1430 430 1430 {lab=VSS}
N 490 1430 520 1430 {lab=#net3}
N -200 1320 570 1320 {lab=#net3}
N -700 1320 -260 1320 {lab=#net3}
N 180 1320 180 1430 {lab=#net3}
N -50 950 -50 1080 {lab=#net4}
N -50 950 320 950 {lab=#net4}
N -530 1320 -530 1430 {lab=#net3}
N 510 1320 510 1430 {lab=#net3}
N 40 1350 550 1350 {lab=#net2}
N 550 1350 550 1390 {lab=#net2}
N 460 1350 460 1390 {lab=#net2}
N 380 1350 380 1390 {lab=#net2}
N 300 1350 300 1390 {lab=#net2}
N 220 1350 220 1390 {lab=#net2}
N 140 1360 140 1390 {lab=#net2}
N 140 1350 140 1360 {lab=#net2}
N 140 1390 550 1390 {lab=#net2}
N -360 1320 -360 1430 {lab=#net3}
N 340 1320 340 1430 {lab=#net3}
N -620 1430 -600 1430 {lab=VSS}
N -620 1390 -620 1430 {lab=VSS}
N -650 1390 -620 1390 {lab=VSS}
N -680 1390 -650 1390 {lab=VSS}
N -680 1390 -680 1430 {lab=VSS}
N 580 1430 600 1430 {lab=VSS}
N 600 1390 600 1430 {lab=VSS}
N 600 1390 630 1390 {lab=VSS}
N 630 1390 660 1390 {lab=VSS}
N 660 1390 660 1430 {lab=VSS}
N -760 1350 -570 1350 {lab=#net2}
N -760 1350 -760 1510 {lab=#net2}
N -760 1510 560 1510 {lab=#net2}
N -660 1010 -660 1040 {lab=EN}
N -410 730 -410 1080 {lab=Vz}
N -130 710 -130 1080 {lab=VOUT}
N -510 830 -510 1010 {lab=EN}
N -660 830 -510 830 {lab=EN}
N -1230 900 -610 900 {lab=IBIAS}
N -610 900 -610 1080 {lab=IBIAS}
N -710 1080 -710 1350 {lab=#net2}
N -470 1290 -470 1350 {lab=#net2}
N -380 1290 -380 1350 {lab=#net2}
N -300 1290 -300 1350 {lab=#net2}
N -220 1290 -220 1350 {lab=#net2}
N -140 1290 -140 1350 {lab=#net2}
N -60 1290 -60 1350 {lab=#net2}
N 40 1290 40 1350 {lab=#net2}
N 120 1290 120 1350 {lab=#net2}
N 200 1290 200 1350 {lab=#net2}
N 280 1290 280 1350 {lab=#net2}
N 360 1290 360 1350 {lab=#net2}
N 450 1290 450 1350 {lab=#net2}
N -470 1510 -470 1530 {lab=#net2}
N -380 1510 -380 1530 {lab=#net2}
N -300 1510 -300 1530 {lab=#net2}
N -220 1510 -220 1530 {lab=#net2}
N -140 1510 -140 1530 {lab=#net2}
N -60 1510 -60 1530 {lab=#net2}
N 40 1510 40 1530 {lab=#net2}
N 120 1510 120 1530 {lab=#net2}
N 200 1510 200 1530 {lab=#net2}
N 280 1510 280 1530 {lab=#net2}
N 360 1510 360 1530 {lab=#net2}
N 450 1510 450 1530 {lab=#net2}
N -620 1250 -590 1250 {lab=VSS}
N -530 1250 -500 1250 {lab=VSS}
N -440 1250 -410 1250 {lab=#net4}
N -350 1250 -330 1250 {lab=VSS}
N -270 1250 -250 1250 {lab=#net4}
N -190 1250 -170 1250 {lab=VSS}
N -110 1250 -90 1250 {lab=#net4}
N -30 1250 10 1250 {lab=VSS}
N 70 1250 90 1250 {lab=#net4}
N 150 1250 170 1250 {lab=VSS}
N 230 1250 250 1250 {lab=#net4}
N 310 1250 330 1250 {lab=VSS}
N 390 1250 420 1250 {lab=#net4}
N 480 1250 500 1250 {lab=VSS}
N 560 1250 580 1250 {lab=VSS}
N 490 1250 490 1290 {lab=VSS}
N 490 1290 530 1290 {lab=VSS}
N 530 1290 570 1290 {lab=VSS}
N 570 1250 570 1290 {lab=VSS}
N 570 1290 610 1290 {lab=VSS}
N 610 1290 640 1290 {lab=VSS}
N 640 1250 640 1290 {lab=VSS}
N 560 1570 580 1570 {lab=VSS}
N 580 1530 580 1570 {lab=VSS}
N 580 1530 610 1530 {lab=VSS}
N 610 1530 640 1530 {lab=VSS}
N 640 1530 640 1570 {lab=VSS}
N 560 1530 560 1570 {lab=VSS}
N 530 1530 560 1530 {lab=VSS}
N 500 1530 530 1530 {lab=VSS}
N 500 1530 500 1570 {lab=VSS}
N 480 1570 500 1570 {lab=VSS}
N 390 1570 420 1570 {lab=#net4}
N 310 1570 330 1570 {lab=VSS}
N 230 1570 250 1570 {lab=#net4}
N 150 1570 170 1570 {lab=VSS}
N 70 1570 90 1570 {lab=#net4}
N -30 1570 10 1570 {lab=VSS}
N -110 1570 -90 1570 {lab=#net4}
N -190 1570 -170 1570 {lab=VSS}
N -270 1570 -250 1570 {lab=#net4}
N -350 1570 -330 1570 {lab=VSS}
N -440 1570 -410 1570 {lab=#net4}
N -530 1570 -500 1570 {lab=VSS}
N -620 1570 -590 1570 {lab=VSS}
N -530 1530 -530 1570 {lab=VSS}
N -560 1530 -530 1530 {lab=VSS}
N -600 1530 -560 1530 {lab=VSS}
N -600 1530 -600 1570 {lab=VSS}
N -620 1530 -620 1570 {lab=VSS}
N -650 1530 -620 1530 {lab=VSS}
N -680 1530 -650 1530 {lab=VSS}
N -680 1530 -680 1570 {lab=VSS}
N -730 1480 800 1480 {lab=VSS}
N -610 1430 -610 1480 {lab=VSS}
N -610 1480 -610 1570 {lab=VSS}
N -650 1430 -650 1480 {lab=VSS}
N -570 1430 -570 1480 {lab=VSS}
N -480 1430 -480 1480 {lab=VSS}
N -440 1430 -440 1480 {lab=VSS}
N -400 1430 -400 1480 {lab=VSS}
N -680 1250 -680 1290 {lab=VSS}
N -680 1290 -650 1290 {lab=VSS}
N -650 1290 -600 1290 {lab=VSS}
N -600 1250 -600 1290 {lab=VSS}
N -610 1290 -560 1290 {lab=VSS}
N -560 1290 -510 1290 {lab=VSS}
N -510 1250 -510 1290 {lab=VSS}
N -650 1570 -650 1590 {lab=VSS}
N -650 1590 -610 1590 {lab=VSS}
N -610 1570 -610 1590 {lab=VSS}
N -560 1570 -560 1590 {lab=VSS}
N -600 1590 -560 1590 {lab=VSS}
N -600 1570 -600 1590 {lab=VSS}
N -470 1570 -470 1590 {lab=VSS}
N -520 1590 -470 1590 {lab=VSS}
N -520 1570 -520 1590 {lab=VSS}
N -510 1480 -510 1570 {lab=VSS}
N -380 1570 -380 1590 {lab=VSS}
N -380 1590 -340 1590 {lab=VSS}
N -340 1570 -340 1590 {lab=VSS}
N -340 1480 -340 1570 {lab=VSS}
N -280 1430 -280 1480 {lab=VSS}
N -320 1430 -320 1480 {lab=VSS}
N -300 1570 -300 1590 {lab=VSS}
N -340 1590 -300 1590 {lab=VSS}
N -180 1480 -180 1570 {lab=VSS}
N -240 1430 -240 1480 {lab=VSS}
N -180 1570 -180 1600 {lab=VSS}
N -220 1600 -180 1600 {lab=VSS}
N -220 1570 -220 1600 {lab=VSS}
N -180 1600 -140 1600 {lab=VSS}
N -140 1570 -140 1600 {lab=VSS}
N -160 1430 -160 1480 {lab=VSS}
N -100 1430 -100 1480 {lab=VSS}
N -50 1430 -50 1450 {lab=VSS}
N -100 1450 -50 1450 {lab=VSS}
N -10 1480 -10 1570 {lab=VSS}
N -60 1570 -60 1600 {lab=VSS}
N -60 1600 -10 1600 {lab=VSS}
N -10 1570 -10 1600 {lab=VSS}
N -10 1600 40 1600 {lab=VSS}
N 40 1570 40 1600 {lab=VSS}
N 40 1430 40 1450 {lab=VSS}
N 40 1450 90 1450 {lab=VSS}
N 90 1430 90 1450 {lab=VSS}
N 90 1450 90 1480 {lab=VSS}
N 160 1480 160 1570 {lab=VSS}
N 120 1570 120 1600 {lab=VSS}
N 120 1600 160 1600 {lab=VSS}
N 160 1570 160 1600 {lab=VSS}
N 200 1570 200 1600 {lab=VSS}
N 160 1600 200 1600 {lab=VSS}
N 140 1430 140 1480 {lab=VSS}
N 260 1430 260 1480 {lab=VSS}
N 220 1430 220 1480 {lab=VSS}
N 320 1480 320 1570 {lab=VSS}
N 280 1570 280 1600 {lab=VSS}
N 280 1600 360 1600 {lab=VSS}
N 360 1570 360 1600 {lab=VSS}
N 320 1570 320 1600 {lab=VSS}
N 300 1430 300 1480 {lab=VSS}
N 380 1430 380 1480 {lab=VSS}
N 460 1430 460 1480 {lab=VSS}
N 550 1430 550 1480 {lab=VSS}
N 590 1430 590 1480 {lab=VSS}
N 410 1430 410 1480 {lab=VSS}
N 490 1480 490 1570 {lab=VSS}
N 450 1570 450 1600 {lab=VSS}
N 450 1600 610 1600 {lab=VSS}
N 610 1570 610 1600 {lab=VSS}
N 530 1570 530 1600 {lab=VSS}
N -680 1200 730 1200 {lab=VSS}
N 800 1200 800 1480 {lab=VSS}
N 730 1200 800 1200 {lab=VSS}
N 800 1480 800 2010 {lab=VSS}
N -650 1200 -650 1250 {lab=VSS}
N -520 1200 -520 1250 {lab=VSS}
N -560 1200 -560 1250 {lab=VSS}
N -470 1200 -470 1250 {lab=VSS}
N -340 1200 -340 1250 {lab=VSS}
N -380 1200 -380 1250 {lab=VSS}
N -300 1200 -300 1250 {lab=VSS}
N -220 1200 -220 1250 {lab=VSS}
N -180 1200 -180 1250 {lab=VSS}
N -140 1200 -140 1250 {lab=VSS}
N -60 1200 -60 1250 {lab=VSS}
N -10 1200 -10 1250 {lab=VSS}
N 40 1200 40 1250 {lab=VSS}
N 120 1200 120 1250 {lab=VSS}
N 160 1200 160 1250 {lab=VSS}
N 200 1200 200 1250 {lab=VSS}
N 280 1200 280 1250 {lab=VSS}
N 320 1200 320 1250 {lab=VSS}
N 360 1200 360 1250 {lab=VSS}
N 450 1200 450 1250 {lab=VSS}
N 490 1200 490 1250 {lab=VSS}
N 530 1200 530 1250 {lab=VSS}
N 570 1200 570 1250 {lab=VSS}
N 610 1200 610 1250 {lab=VSS}
N 570 1320 730 1320 {lab=#net3}
N -330 1130 730 1130 {lab=#net3}
N -330 1080 -330 1130 {lab=#net3}
N -660 1670 910 1670 {lab=#net4}
N 910 950 910 1670 {lab=#net4}
N 320 950 910 950 {lab=#net4}
N -680 1160 910 1160 {lab=#net4}
N -420 1160 -420 1250 {lab=#net4}
N -260 1160 -260 1250 {lab=#net4}
N -100 1160 -100 1250 {lab=#net4}
N 80 1160 80 1250 {lab=#net4}
N 240 1160 240 1250 {lab=#net4}
N 400 1160 400 1250 {lab=#net4}
N -420 1570 -420 1670 {lab=#net4}
N -260 1570 -260 1670 {lab=#net4}
N -100 1570 -100 1670 {lab=#net4}
N 80 1570 80 1670 {lab=#net4}
N 240 1570 240 1670 {lab=#net4}
N 400 1570 400 1670 {lab=#net4}
N -90 -520 -90 -490 {lab=VOUT}
N -130 710 -90 710 {lab=VOUT}
N -1220 640 -1220 900 {lab=IBIAS}
N 1160 740 1160 1880 {lab=VSS}
N 800 1880 1160 1880 {lab=VSS}
N -750 1080 -750 1110 {lab=VSS}
N -750 1110 -660 1110 {lab=VSS}
N -660 1080 -660 1110 {lab=VSS}
N -660 1110 -570 1110 {lab=VSS}
N -570 1080 -570 1110 {lab=VSS}
N -570 1110 -460 1110 {lab=VSS}
N -460 1080 -460 1110 {lab=VSS}
N -460 1110 -370 1110 {lab=VSS}
N -370 1080 -370 1110 {lab=VSS}
N -370 1110 -280 1110 {lab=VSS}
N -280 1080 -280 1110 {lab=VSS}
N -280 1110 -170 1110 {lab=VSS}
N -170 1080 -170 1110 {lab=VSS}
N -170 1110 -90 1110 {lab=VSS}
N -90 1080 -90 1110 {lab=VSS}
N -90 1110 0 1110 {lab=VSS}
N 80 1080 80 1110 {lab=VSS}
N 0 1110 490 1110 {lab=VSS}
N 490 740 490 1110 {lab=VSS}
N 490 1570 490 1600 {lab=VSS}
N 630 1430 630 1480 {lab=VSS}
N 730 1320 750 1320 {lab=#net3}
N 750 1130 750 1320 {lab=#net3}
N 730 1130 750 1130 {lab=#net3}
N -200 1040 -200 1080 {lab=VOUT}
N -200 1040 -180 1040 {lab=VOUT}
N 10 -1390 30 -1390 {lab=Vpo}
N 200 -1260 210 -1260 {lab=Vpo}
N -70 -1330 300 -1330 {lab=Vpo}
N 170 -1330 170 -1310 {lab=Vpo}
N -20 -1350 -20 -1330 {lab=Vpo}
N -20 -1330 -20 -1300 {lab=Vpo}
N 50 -1330 50 -1300 {lab=Vpo}
N -300 -1450 650 -1450 {lab=VDD}
N -300 -1160 650 -1160 {lab=VDD}
N 650 -1450 650 -1160 {lab=VDD}
N 650 -1830 650 -1450 {lab=VDD}
N 170 -1350 170 -1330 {lab=Vpo}
N 240 -1350 240 -1330 {lab=Vpo}
N 240 -1330 240 -1310 {lab=Vpo}
N 200 -1390 210 -1390 {lab=Vout1}
N 10 -1260 20 -1260 {lab=Vout1}
N 90 -1390 140 -1390 {lab=VDD}
N 110 -1450 110 -1390 {lab=VDD}
N 20 -1390 20 -1350 {lab=Vpo}
N 20 -1350 60 -1350 {lab=Vpo}
N -20 -1350 20 -1350 {lab=Vpo}
N 170 -1450 170 -1390 {lab=VDD}
N 240 -1450 240 -1390 {lab=VDD}
N 170 -1310 170 -1300 {lab=Vpo}
N 240 -1310 240 -1300 {lab=Vpo}
N -20 -1260 -20 -1160 {lab=VDD}
N 50 -1260 50 -1160 {lab=VDD}
N 170 -1260 170 -1160 {lab=VDD}
N 240 -1260 240 -1160 {lab=VDD}
N 80 -1260 130 -1260 {lab=VDD}
N 130 -1260 140 -1260 {lab=VDD}
N 110 -1260 110 -1160 {lab=VDD}
N 170 -1300 240 -1300 {lab=Vpo}
N 60 -1350 60 -1330 {lab=Vpo}
N -490 -1200 -490 -870 {lab=Vpo}
N 200 -1490 200 -1390 {lab=Vout1}
N -100 -1490 -20 -1490 {lab=Vout1}
N -20 -1490 60 -1490 {lab=Vout1}
N 60 -1490 170 -1490 {lab=Vout1}
N 170 -1490 240 -1490 {lab=Vout1}
N 240 -1490 320 -1490 {lab=Vout1}
N 10 -1260 10 -1130 {lab=Vout1}
N -100 -1130 -20 -1130 {lab=Vout1}
N -20 -1130 10 -1130 {lab=Vout1}
N 10 -1130 50 -1130 {lab=Vout1}
N 50 -1130 170 -1130 {lab=Vout1}
N 170 -1130 240 -1130 {lab=Vout1}
N 240 -1130 320 -1130 {lab=Vout1}
N -100 -1090 -100 -1000 {lab=VDD}
N -100 -1000 320 -1000 {lab=VDD}
N 320 -1090 320 -1000 {lab=VDD}
N 240 -1090 240 -1000 {lab=VDD}
N 170 -1090 170 -1000 {lab=VDD}
N 50 -1090 50 -1000 {lab=VDD}
N -20 -1090 -20 -1000 {lab=VDD}
N -260 -1090 -220 -1090 {lab=VOUT}
N -260 -1130 -260 -1090 {lab=VOUT}
N -290 -1130 -260 -1130 {lab=VOUT}
N -320 -1130 -290 -1130 {lab=VOUT}
N -320 -1130 -320 -1090 {lab=VOUT}
N -150 -1160 -150 -1090 {lab=VDD}
N -130 -1090 -130 -1000 {lab=VDD}
N -130 -1000 -100 -1000 {lab=VDD}
N 540 -1090 560 -1090 {lab=VDD}
N 360 -1090 360 -1000 {lab=VDD}
N 320 -1000 360 -1000 {lab=VDD}
N 560 -1130 560 -1090 {lab=VDD}
N 560 -1130 590 -1130 {lab=VDD}
N 590 -1130 620 -1130 {lab=VDD}
N 620 -1130 620 -1090 {lab=VDD}
N 360 -1160 360 -1090 {lab=VDD}
N 80 -1090 140 -1090 {lab=VOUT}
N 110 -1090 110 -900 {lab=VOUT}
N 110 -900 770 -900 {lab=VOUT}
N -70 -1090 -50 -1090 {lab=VOUT}
N 200 -1090 210 -1090 {lab=VDD}
N 270 -1090 290 -1090 {lab=VOUT}
N 210 -1090 210 -1000 {lab=VDD}
N 10 -1090 20 -1090 {lab=VDD}
N 10 -1090 10 -1000 {lab=VDD}
N -60 -1090 -60 -1050 {lab=VOUT}
N -60 -1050 110 -1050 {lab=VOUT}
N 280 -1090 280 -1040 {lab=VOUT}
N 110 -1040 280 -1040 {lab=VOUT}
N 590 -1090 590 -1000 {lab=VDD}
N 550 -1000 590 -1000 {lab=VDD}
N -290 -1090 -290 -1000 {lab=VDD}
N -290 -1000 -220 -1000 {lab=VDD}
N 430 -1530 460 -1530 {lab=VOUT}
N 460 -1530 460 -1490 {lab=VOUT}
N 460 -1490 490 -1490 {lab=VOUT}
N 490 -1490 520 -1490 {lab=VOUT}
N 520 -1530 520 -1490 {lab=VOUT}
N -150 -1530 -130 -1530 {lab=VDD}
N -140 -1530 -140 -1450 {lab=VDD}
N -180 -1490 -150 -1490 {lab=Vout1}
N -180 -1620 -180 -1530 {lab=VDD}
N -180 -1620 320 -1620 {lab=VDD}
N 320 -1620 320 -1530 {lab=VDD}
N 360 -1620 360 -1530 {lab=VDD}
N 320 -1620 360 -1620 {lab=VDD}
N 360 -1530 360 -1450 {lab=VDD}
N 490 -1620 490 -1530 {lab=VDD}
N 270 -1530 290 -1530 {lab=VOUT}
N 200 -1530 210 -1530 {lab=VDD}
N 210 -1620 210 -1530 {lab=VDD}
N 90 -1530 140 -1530 {lab=VOUT}
N 10 -1530 30 -1530 {lab=VDD}
N 20 -1620 20 -1530 {lab=VDD}
N -20 -1620 -20 -1530 {lab=VDD}
N 60 -1620 60 -1530 {lab=VDD}
N 170 -1620 170 -1530 {lab=VDD}
N 240 -1620 240 -1530 {lab=VDD}
N -100 -1620 -100 -1530 {lab=VDD}
N -140 -1620 -140 -1530 {lab=VDD}
N -70 -1530 -50 -1530 {lab=VOUT}
N -60 -1650 -60 -1530 {lab=VOUT}
N -60 -1650 280 -1650 {lab=VOUT}
N 280 -1650 280 -1530 {lab=VOUT}
N 110 -1650 110 -1530 {lab=VOUT}
N -10 -1710 -10 -1650 {lab=VOUT}
N -360 -1710 -10 -1710 {lab=VOUT}
N -360 -900 110 -900 {lab=VOUT}
N -10 -1710 600 -1710 {lab=VOUT}
N -120 -1490 -100 -1490 {lab=Vout1}
N 320 -1490 340 -1490 {lab=Vout1}
N 320 -1130 340 -1130 {lab=Vout1}
N -490 -870 -490 -760 {lab=Vpo}
N 200 -1300 200 -1260 {lab=Vpo}
N -50 -1260 -50 -1160 {lab=VDD}
N -150 -1490 -120 -1490 {lab=Vout1}
N -230 -1530 -210 -1530 {lab=VOUT}
N -260 -1490 -180 -1490 {lab=Vout1}
N -260 -1620 -260 -1530 {lab=VDD}
N -260 -1620 -180 -1620 {lab=VDD}
N -310 -1530 -290 -1530 {lab=VDD}
N -310 -1530 -310 -1490 {lab=VDD}
N -340 -1490 -310 -1490 {lab=VDD}
N -370 -1490 -340 -1490 {lab=VDD}
N -370 -1530 -370 -1490 {lab=VDD}
N -340 -1620 -340 -1530 {lab=VDD}
N -340 -1620 -260 -1620 {lab=VDD}
N -300 -1620 -300 -1530 {lab=VDD}
N -430 -1710 -430 -900 {lab=VOUT}
N -430 -900 -360 -900 {lab=VOUT}
N -430 -1710 -360 -1710 {lab=VOUT}
N 350 -1530 370 -1530 {lab=VDD}
N 340 -1490 400 -1490 {lab=Vout1}
N 520 -1530 530 -1530 {lab=VOUT}
N 520 -1490 560 -1490 {lab=VOUT}
N 560 -1490 590 -1490 {lab=VOUT}
N 590 -1530 590 -1490 {lab=VOUT}
N 560 -1620 560 -1530 {lab=VDD}
N 490 -1620 560 -1620 {lab=VDD}
N -490 -1330 -70 -1330 {lab=Vpo}
N -490 -1330 -490 -1200 {lab=Vpo}
N 200 -1330 200 -1300 {lab=Vpo}
N 20 -1350 20 -1330 {lab=Vpo}
N -20 -1450 -20 -1390 {lab=VDD}
N -70 -1390 -50 -1390 {lab=VDD}
N -70 -1390 -70 -1350 {lab=VDD}
N -100 -1350 -70 -1350 {lab=VDD}
N -130 -1350 -100 -1350 {lab=VDD}
N -130 -1390 -130 -1350 {lab=VDD}
N 270 -1390 290 -1390 {lab=VDD}
N 280 -1390 280 -1350 {lab=VDD}
N 280 -1350 320 -1350 {lab=VDD}
N 320 -1350 350 -1350 {lab=VDD}
N 350 -1390 350 -1350 {lab=VDD}
N -60 -1450 -60 -1390 {lab=VDD}
N 280 -1450 280 -1390 {lab=VDD}
N 320 -1450 320 -1390 {lab=VDD}
N -100 -1450 -100 -1390 {lab=VDD}
N -70 -1260 -50 -1260 {lab=VDD}
N -70 -1300 -70 -1260 {lab=VDD}
N -100 -1300 -70 -1300 {lab=VDD}
N -130 -1300 -100 -1300 {lab=VDD}
N -130 -1300 -130 -1260 {lab=VDD}
N -100 -1260 -100 -1160 {lab=VDD}
N 270 -1260 290 -1260 {lab=VDD}
N 290 -1300 290 -1260 {lab=VDD}
N 290 -1300 320 -1300 {lab=VDD}
N 320 -1300 350 -1300 {lab=VDD}
N 350 -1300 350 -1260 {lab=VDD}
N 320 -1260 320 -1170 {lab=VDD}
N 320 -1170 320 -1160 {lab=VDD}
N -160 -1390 -130 -1390 {lab=VDD}
N -160 -1390 -160 -1350 {lab=VDD}
N -190 -1350 -160 -1350 {lab=VDD}
N -220 -1350 -190 -1350 {lab=VDD}
N -220 -1390 -220 -1350 {lab=VDD}
N -240 -1390 -220 -1390 {lab=VDD}
N -240 -1390 -240 -1350 {lab=VDD}
N -270 -1350 -240 -1350 {lab=VDD}
N -300 -1350 -270 -1350 {lab=VDD}
N -300 -1390 -300 -1350 {lab=VDD}
N -320 -1390 -300 -1390 {lab=VDD}
N -320 -1390 -320 -1350 {lab=VDD}
N -350 -1350 -320 -1350 {lab=VDD}
N -380 -1350 -350 -1350 {lab=VDD}
N -380 -1390 -380 -1350 {lab=VDD}
N -350 -1410 -350 -1390 {lab=VDD}
N -350 -1410 -270 -1410 {lab=VDD}
N -270 -1410 -270 -1390 {lab=VDD}
N -270 -1410 -190 -1410 {lab=VDD}
N -190 -1410 -190 -1390 {lab=VDD}
N -190 -1410 -100 -1410 {lab=VDD}
N 350 -1390 380 -1390 {lab=VDD}
N 380 -1390 380 -1350 {lab=VDD}
N 380 -1350 410 -1350 {lab=VDD}
N 410 -1350 440 -1350 {lab=VDD}
N 440 -1390 440 -1350 {lab=VDD}
N 440 -1390 460 -1390 {lab=VDD}
N 460 -1390 460 -1350 {lab=VDD}
N 460 -1350 490 -1350 {lab=VDD}
N 490 -1350 520 -1350 {lab=VDD}
N 520 -1390 520 -1350 {lab=VDD}
N 520 -1390 540 -1390 {lab=VDD}
N 540 -1390 540 -1350 {lab=VDD}
N 540 -1350 570 -1350 {lab=VDD}
N 570 -1350 600 -1350 {lab=VDD}
N 600 -1390 600 -1350 {lab=VDD}
N 570 -1410 570 -1390 {lab=VDD}
N 490 -1410 570 -1410 {lab=VDD}
N 490 -1410 490 -1390 {lab=VDD}
N 410 -1410 490 -1410 {lab=VDD}
N 410 -1410 410 -1390 {lab=VDD}
N 320 -1410 410 -1410 {lab=VDD}
N 630 -1710 630 -900 {lab=VOUT}
N 600 -1710 630 -1710 {lab=VOUT}
N -160 -1260 -130 -1260 {lab=VDD}
N -160 -1300 -160 -1260 {lab=VDD}
N -190 -1300 -160 -1300 {lab=VDD}
N -220 -1300 -190 -1300 {lab=VDD}
N -220 -1300 -220 -1260 {lab=VDD}
N -240 -1260 -220 -1260 {lab=VDD}
N -240 -1300 -240 -1260 {lab=VDD}
N -270 -1300 -240 -1300 {lab=VDD}
N -300 -1300 -270 -1300 {lab=VDD}
N -300 -1300 -300 -1260 {lab=VDD}
N -320 -1260 -300 -1260 {lab=VDD}
N -320 -1300 -320 -1260 {lab=VDD}
N -350 -1300 -320 -1300 {lab=VDD}
N -380 -1300 -350 -1300 {lab=VDD}
N -380 -1300 -380 -1260 {lab=VDD}
N -350 -1260 -350 -1240 {lab=VDD}
N -350 -1240 -270 -1240 {lab=VDD}
N -270 -1260 -270 -1240 {lab=VDD}
N -270 -1240 -190 -1240 {lab=VDD}
N -190 -1260 -190 -1240 {lab=VDD}
N -190 -1240 -100 -1240 {lab=VDD}
N 380 -1300 380 -1260 {lab=VDD}
N 380 -1300 410 -1300 {lab=VDD}
N 410 -1300 440 -1300 {lab=VDD}
N 440 -1300 440 -1260 {lab=VDD}
N 440 -1260 460 -1260 {lab=VDD}
N 460 -1300 460 -1260 {lab=VDD}
N 460 -1300 490 -1300 {lab=VDD}
N 490 -1300 520 -1300 {lab=VDD}
N 520 -1300 520 -1260 {lab=VDD}
N 520 -1260 540 -1260 {lab=VDD}
N 540 -1300 540 -1260 {lab=VDD}
N 540 -1300 570 -1300 {lab=VDD}
N 570 -1300 600 -1300 {lab=VDD}
N 600 -1300 600 -1260 {lab=VDD}
N 570 -1260 570 -1240 {lab=VDD}
N 490 -1240 570 -1240 {lab=VDD}
N 490 -1260 490 -1240 {lab=VDD}
N 410 -1240 490 -1240 {lab=VDD}
N 410 -1260 410 -1240 {lab=VDD}
N 320 -1240 410 -1240 {lab=VDD}
N 350 -1260 380 -1260 {lab=VDD}
N -150 -1090 -130 -1090 {lab=VDD}
N -220 -1090 -210 -1090 {lab=VOUT}
N -220 -1000 -130 -1000 {lab=VDD}
N -360 -1130 -320 -1130 {lab=VOUT}
N -330 -1090 -320 -1090 {lab=VOUT}
N -390 -1130 -390 -1090 {lab=VOUT}
N -390 -1130 -360 -1130 {lab=VOUT}
N -360 -1090 -360 -1000 {lab=VDD}
N -360 -1000 -290 -1000 {lab=VDD}
N -220 -1650 -220 -1530 {lab=VOUT}
N -220 -1650 -60 -1650 {lab=VOUT}
N 280 -1650 440 -1650 {lab=VOUT}
N -230 -1090 -230 -1050 {lab=VOUT}
N -230 -1050 -60 -1050 {lab=VOUT}
N 350 -1090 370 -1090 {lab=VDD}
N 400 -1090 400 -1000 {lab=VDD}
N 360 -1000 400 -1000 {lab=VDD}
N 340 -1130 400 -1130 {lab=Vout1}
N -180 -1130 -100 -1130 {lab=Vout1}
N 430 -1090 450 -1090 {lab=VOUT}
N 510 -1160 510 -1090 {lab=VDD}
N 480 -1090 480 -1060 {lab=VDD}
N 480 -1060 510 -1060 {lab=VDD}
N 510 -1090 510 -1060 {lab=VDD}
N 510 -1090 540 -1090 {lab=VDD}
N 400 -1000 550 -1000 {lab=VDD}
N 440 -1090 440 -1040 {lab=VOUT}
N 280 -1040 440 -1040 {lab=VOUT}
N 400 -1130 480 -1130 {lab=Vout1}
N -490 -760 -490 -710 {lab=Vpo}
N -260 -1490 -260 -1470 {lab=Vout1}
N -180 -1150 -180 -1130 {lab=Vout1}
N -410 -1150 -180 -1150 {lab=Vout1}
N -410 -1470 -410 -1150 {lab=Vout1}
N -410 -1470 -260 -1470 {lab=Vout1}
N -410 -1150 -410 -710 {lab=Vout1}
N -410 -710 -330 -710 {lab=Vout1}
N 770 -900 770 -680 {lab=VOUT}
N -90 -680 770 -680 {lab=VOUT}
N -90 -680 -90 -670 {lab=VOUT}
N 440 -1650 440 -1530 {lab=VOUT}
N 400 -1620 400 -1530 {lab=VDD}
N 360 -1620 400 -1620 {lab=VDD}
N 400 -1620 490 -1620 {lab=VDD}
N -180 -1090 -180 -1000 {lab=VDD}
N 60 -1450 60 -1390 {lab=VDD}
N 270 -1260 270 -1160 {lab=VDD}
N -400 -190 -400 -160 {lab=VN}
N -400 -190 -120 -190 {lab=VN}
N -120 -190 -120 -160 {lab=VN}
N -190 -190 -190 -160 {lab=VN}
N -190 100 -190 150 {lab=VP}
N -190 150 100 150 {lab=VP}
N -120 100 -120 150 {lab=VP}
N -120 -190 90 -190 {lab=VN}
N 90 -190 90 -160 {lab=VN}
N -400 100 -400 150 {lab=VP}
N -400 150 -190 150 {lab=VP}
N 90 100 90 150 {lab=VP}
N -580 -190 -400 -190 {lab=VN}
N 100 150 300 150 {lab=VP}
N -370 -120 -360 -120 {lab=Vz}
N -300 -120 -290 -120 {lab=Vout1}
N -230 -120 -220 -120 {lab=Vz}
N -160 -120 -150 -120 {lab=Vpo}
N -90 -120 -80 -120 {lab=Vz}
N -20 -120 -10 -120 {lab=Vout1}
N 50 -120 60 -120 {lab=Vz}
N -370 60 -360 60 {lab=Vz}
N -230 60 -220 60 {lab=Vz}
N -160 60 -150 60 {lab=Vout1}
N -90 60 -80 60 {lab=Vz}
N -20 60 -10 60 {lab=Vpo}
N 50 60 60 60 {lab=Vz}
N -480 190 -330 190 {lab=VN}
N -330 100 -330 190 {lab=VN}
N -260 100 -260 190 {lab=VN}
N -330 190 -260 190 {lab=VN}
N -260 190 -50 190 {lab=VN}
N -50 100 -50 190 {lab=VN}
N -50 190 20 190 {lab=VN}
N 20 100 20 190 {lab=VN}
N 20 -250 170 -250 {lab=VP}
N 20 -250 20 -160 {lab=VP}
N -50 -250 -50 -160 {lab=VP}
N -50 -250 20 -250 {lab=VP}
N -260 -250 -50 -250 {lab=VP}
N -260 -250 -260 -160 {lab=VP}
N -330 -250 -260 -250 {lab=VP}
N -330 -250 -330 -160 {lab=VP}
N -160 -300 -160 -120 {lab=Vpo}
N -430 -300 -430 -120 {lab=Vpo}
N 120 -300 120 -120 {lab=Vpo}
N -430 -300 -160 -300 {lab=Vpo}
N -160 -300 120 -300 {lab=Vpo}
N -160 60 -160 240 {lab=Vout1}
N -430 60 -430 240 {lab=Vout1}
N 120 60 120 240 {lab=Vout1}
N -430 240 -160 240 {lab=Vout1}
N -160 240 120 240 {lab=Vout1}
N -430 -530 -430 -300 {lab=Vpo}
N -300 60 -290 60 {lab=Vpo}
N -300 60 -300 300 {lab=Vpo}
N -10 60 -10 300 {lab=Vpo}
N -300 300 240 300 {lab=Vpo}
N 240 -300 240 300 {lab=Vpo}
N 120 -300 240 -300 {lab=Vpo}
N -10 -360 -10 -120 {lab=Vout1}
N -300 -360 -300 -120 {lab=Vout1}
N -550 -360 -10 -360 {lab=Vout1}
N -550 -360 -550 240 {lab=Vout1}
N -550 240 -430 240 {lab=Vout1}
N -810 -190 -580 -190 {lab=VN}
N 300 150 490 150 {lab=VP}
N -690 -30 380 -30 {lab=Vz}
N -690 -30 -690 410 {lab=Vz}
N -690 410 -160 410 {lab=Vz}
N 380 -30 380 410 {lab=Vz}
N -160 410 380 410 {lab=Vz}
N -550 -490 -550 -360 {lab=Vout1}
N -550 -490 -340 -490 {lab=Vout1}
N -340 -530 -340 -490 {lab=Vout1}
N -370 -120 -370 -30 {lab=Vz}
N -230 -120 -230 -30 {lab=Vz}
N -80 -120 -80 -30 {lab=Vz}
N 60 -120 60 -30 {lab=Vz}
N -370 -30 -370 60 {lab=Vz}
N -230 -30 -230 60 {lab=Vz}
N -80 -30 -80 50 {lab=Vz}
N 60 -30 60 60 {lab=Vz}
N -400 -120 -400 -80 {lab=VSS}
N -400 -80 90 -80 {lab=VSS}
N 90 -120 90 -80 {lab=VSS}
N 20 -120 20 -80 {lab=VSS}
N -50 -120 -50 -80 {lab=VSS}
N -190 -120 -190 -80 {lab=VSS}
N -260 -120 -260 -80 {lab=VSS}
N -330 -120 -330 -80 {lab=VSS}
N -400 30 -400 60 {lab=VSS}
N -400 30 -330 30 {lab=VSS}
N -330 30 -330 60 {lab=VSS}
N -330 30 -260 30 {lab=VSS}
N -260 30 -260 60 {lab=VSS}
N -260 30 -190 30 {lab=VSS}
N -190 30 -190 60 {lab=VSS}
N -190 30 -120 30 {lab=VSS}
N -120 30 -120 60 {lab=VSS}
N -120 30 -50 30 {lab=VSS}
N -50 30 -50 60 {lab=VSS}
N -50 30 20 30 {lab=VSS}
N 20 30 20 60 {lab=VSS}
N 20 30 90 30 {lab=VSS}
N 90 30 90 60 {lab=VSS}
N -490 -610 -430 -610 {lab=Vpo}
N -340 -610 -330 -610 {lab=Vout1}
N -160 -10 -160 30 {lab=VSS}
N -160 -80 -160 -10 {lab=VSS}
N -410 410 -410 730 {lab=Vz}
N 490 740 990 740 {lab=VSS}
N 990 740 1160 740 {lab=VSS}
N -90 710 370 710 {lab=VOUT}
N 370 710 540 710 {lab=VOUT}
N 540 710 770 710 {lab=VOUT}
N 770 -410 770 710 {lab=VOUT}
N -80 50 -80 60 {lab=Vz}
N -120 -120 -120 -80 {lab=VSS}
N -600 -90 -400 -90 {lab=VSS}
N -410 -440 -410 -400 {lab=VSS}
N -410 -440 140 -440 {lab=VSS}
N 140 -440 140 -400 {lab=VSS}
N -410 -400 140 -400 {lab=VSS}
N -470 320 -470 360 {lab=VSS}
N -470 320 80 320 {lab=VSS}
N 80 320 80 360 {lab=VSS}
N -470 360 80 360 {lab=VSS}
N -90 -490 -90 -470 {lab=VOUT}
N -90 -470 150 -470 {lab=VOUT}
N 150 -470 150 -370 {lab=VOUT}
N 150 -370 770 -370 {lab=VOUT}
N -440 -400 -410 -400 {lab=VSS}
N -440 -440 -440 -400 {lab=VSS}
N -470 -440 -440 -440 {lab=VSS}
N -500 -440 -470 -440 {lab=VSS}
N -500 -440 -500 -400 {lab=VSS}
N -500 -400 -470 -400 {lab=VSS}
N -470 -400 -440 -400 {lab=VSS}
N 140 -400 160 -400 {lab=VSS}
N 160 -440 160 -400 {lab=VSS}
N 160 -440 190 -440 {lab=VSS}
N 190 -440 220 -440 {lab=VSS}
N 220 -440 220 -400 {lab=VSS}
N 160 -400 220 -400 {lab=VSS}
N 80 360 110 360 {lab=VSS}
N 80 320 140 320 {lab=VSS}
N 140 320 170 320 {lab=VSS}
N 170 320 170 360 {lab=VSS}
N 110 360 170 360 {lab=VSS}
N -550 360 -470 360 {lab=VSS}
N -550 320 -550 360 {lab=VSS}
N -550 320 -470 320 {lab=VSS}
N -430 -610 -430 -590 {lab=Vpo}
N -340 -550 -340 -530 {lab=Vout1}
N -430 -590 -430 -530 {lab=Vpo}
N -340 -610 -340 -550 {lab=Vout1}
N 800 2010 800 2070 {lab=VSS}
N -590 190 -480 190 {lab=VN}
N -590 -190 -590 190 {lab=VN}
N -450 -120 -430 -120 {lab=Vpo}
N -480 -190 -480 -160 {lab=VN}
N -480 -120 -480 -90 {lab=VSS}
N -510 -120 -510 -30 {lab=Vz}
N -610 -120 -510 -120 {lab=Vz}
N -670 -160 -640 -160 {lab=VSS}
N -670 -160 -670 -120 {lab=VSS}
N -640 -120 -640 -90 {lab=VSS}
N -640 -90 -600 -90 {lab=VSS}
N -670 -120 -670 -90 {lab=VSS}
N -670 -90 -640 -90 {lab=VSS}
N -450 60 -430 60 {lab=Vout1}
N -480 30 -480 60 {lab=VSS}
N -480 30 -400 30 {lab=VSS}
N -510 -30 -510 60 {lab=Vz}
N -480 100 -480 150 {lab=VP}
N -480 150 -400 150 {lab=VP}
N -610 60 -510 60 {lab=Vz}
N -670 60 -670 100 {lab=VSS}
N -670 100 -640 100 {lab=VSS}
N -640 30 -640 60 {lab=VSS}
N -640 30 -480 30 {lab=VSS}
N -670 30 -670 60 {lab=VSS}
N -670 30 -640 30 {lab=VSS}
N 170 -250 310 -250 {lab=VP}
N 310 -250 310 150 {lab=VP}
N 120 -120 140 -120 {lab=Vpo}
N 170 -190 170 -160 {lab=VN}
N 90 -190 170 -190 {lab=VN}
N 90 -80 170 -80 {lab=VSS}
N 170 -120 170 -80 {lab=VSS}
N 200 -120 200 -30 {lab=Vz}
N 120 60 140 60 {lab=Vout1}
N 170 100 170 150 {lab=VP}
N 200 -30 200 60 {lab=Vz}
N 170 30 170 60 {lab=VSS}
N 90 30 170 30 {lab=VSS}
N 200 -120 320 -120 {lab=Vz}
N 350 -160 380 -160 {lab=VSS}
N 380 -160 380 -120 {lab=VSS}
N 350 -120 350 -80 {lab=VSS}
N 170 -80 350 -80 {lab=VSS}
N 380 -120 380 -80 {lab=VSS}
N 350 -80 380 -80 {lab=VSS}
N 200 60 390 60 {lab=Vz}
N 420 40 420 60 {lab=VSS}
N 170 30 420 30 {lab=VSS}
N 420 30 420 40 {lab=VSS}
N 450 60 470 60 {lab=VSS}
N 470 60 470 100 {lab=VSS}
N 420 100 470 100 {lab=VSS}
N 470 30 470 60 {lab=VSS}
N 420 30 470 30 {lab=VSS}
N -60 1080 -40 1080 {lab=#net4}
N -10 1010 -10 1040 {lab=EN}
N -90 1010 -10 1010 {lab=EN}
N 20 990 20 1080 {lab=VOUT}
N -130 990 20 990 {lab=VOUT}
N -10 1080 -10 1110 {lab=VSS}
N -630 -400 -500 -400 {lab=VSS}
N -630 -410 -630 -400 {lab=VSS}
N -600 -410 -600 -400 {lab=VSS}
N -570 -410 -570 -400 {lab=VSS}
N -630 -450 -630 -410 {lab=VSS}
N -630 -450 -600 -450 {lab=VSS}
N -600 -450 -570 -450 {lab=VSS}
N -570 -450 -570 -410 {lab=VSS}
N 220 -400 240 -400 {lab=VSS}
N 240 -440 240 -400 {lab=VSS}
N 240 -440 270 -440 {lab=VSS}
N 270 -440 300 -440 {lab=VSS}
N 300 -440 300 -400 {lab=VSS}
N 220 -400 270 -400 {lab=VSS}
N 270 -400 300 -400 {lab=VSS}
N -570 360 -550 360 {lab=VSS}
N -570 320 -570 360 {lab=VSS}
N -600 320 -570 320 {lab=VSS}
N -630 320 -600 320 {lab=VSS}
N -630 320 -630 360 {lab=VSS}
N -630 360 -600 360 {lab=VSS}
N -600 360 -570 360 {lab=VSS}
N 170 360 180 360 {lab=VSS}
N 180 320 180 360 {lab=VSS}
N 180 320 210 320 {lab=VSS}
N 210 320 240 320 {lab=VSS}
N 240 320 240 360 {lab=VSS}
N 180 360 240 360 {lab=VSS}
N 790 1950 800 1950 {lab=VSS}
C {iopin.sym} 800 2070 1 0 {name=p4 lab=VSS}
C {lab_wire.sym} -820 -190 0 0 {name=p7 sig_type=std_logic lab=VN}
C {lab_wire.sym} -490 -640 0 0 {name=p8 sig_type=std_logic lab=Vpo}
C {lab_wire.sym} 510 150 0 0 {name=p9 sig_type=std_logic lab=VP}
C {devices/launcher.sym} -810 570 0 0 {name=h15
descr="Annotate OP" 
tclcommand="set show_hidden_texts 1; xschem annotate_op"
}
C {lab_wire.sym} -180 -700 0 0 {name=p10 sig_type=std_logic lab=Vout1}
C {lab_wire.sym} -690 170 0 0 {name=p11 sig_type=std_logic lab=Vz}
C {iopin.sym} 650 -1830 3 0 {name=p3 lab=VDD}
C {iopin.sym} -1220 360 3 0 {name=p6 lab=IBIAS}
C {opin.sym} 220 -610 0 0 {name=p13 lab=VOUT}
C {lab_wire.sym} 40 -610 0 0 {name=p21 sig_type=std_logic lab=VOUT}
C {iopin.sym} -750 830 2 0 {name=p5 lab=EN}
C {iopin.sym} -850 -190 2 0 {name=p12 lab=VN}
C {iopin.sym} 520 150 0 0 {name=p1 lab=VP}
C {lab_wire.sym} -670 -90 2 1 {name=p18 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -240 -660 0 0 {name=p14 sig_type=std_logic lab=VSS}
C {sky130_fd_pr/cap_mim_m3_1.sym} -180 -570 0 0 {name=C2 model=cap_mim_m3_1 W=16 L=16 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -750 1060 3 1 {name=M5
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -660 1060 1 0 {name=M6
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -570 1060 3 1 {name=M8
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -460 1060 3 1 {name=M9
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -370 1060 3 1 {name=M10
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -280 1060 3 1 {name=M11
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -90 1060 3 1 {name=M13
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -170 1060 1 0 {name=M14
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 80 1060 3 1 {name=M15
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -50 1410 1 0 {name=M16
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 40 1410 3 1 {name=M17
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -160 1410 3 1 {name=M18
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -240 1410 1 0 {name=M19
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -320 1410 3 1 {name=M20
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -400 1410 1 0 {name=M21
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -480 1410 3 1 {name=M22
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -570 1410 1 0 {name=M23
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 140 1410 1 0 {name=M24
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 220 1410 3 1 {name=M25
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 300 1410 1 0 {name=M26
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 380 1410 3 1 {name=M27
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 460 1410 1 0 {name=M28
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 550 1410 3 1 {name=M29
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -650 1410 3 1 {name=M30
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 630 1410 1 0 {name=M31
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -60 1270 3 0 {name=M32
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -140 1270 1 1 {name=M33
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -220 1270 3 0 {name=M34
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -300 1270 1 1 {name=M35
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -380 1270 3 0 {name=M36
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -470 1270 1 1 {name=M37
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 40 1270 1 1 {name=M38
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 120 1270 3 0 {name=M39
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 200 1270 1 1 {name=M40
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 280 1270 3 0 {name=M41
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 360 1270 1 1 {name=M42
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 450 1270 3 0 {name=M43
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 530 1270 1 1 {name=M44
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -560 1270 3 0 {name=M45
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -650 1270 3 0 {name=M46
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 610 1270 1 1 {name=M47
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -60 1550 3 1 {name=M48
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -140 1550 1 0 {name=M49
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -220 1550 3 1 {name=M50
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -300 1550 1 0 {name=M51
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -380 1550 3 1 {name=M52
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -470 1550 1 0 {name=M53
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 40 1550 1 0 {name=M54
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 120 1550 3 1 {name=M55
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 200 1550 1 0 {name=M56
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 280 1550 3 1 {name=M57
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 360 1550 1 0 {name=M58
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 450 1550 3 1 {name=M59
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 530 1550 1 0 {name=M60
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -560 1550 3 1 {name=M61
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -650 1550 3 1 {name=M62
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 610 1550 1 0 {name=M63
W=3
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -20 -1370 3 0 {name=M68
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 60 -1370 1 1 {name=M69
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 170 -1280 3 1 {name=M70
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 240 -1280 1 0 {name=M71
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -20 -1280 3 1 {name=M72
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 50 -1280 1 0 {name=M73
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 170 -1370 3 0 {name=M74
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 240 -1370 1 1 {name=M75
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -20 -1510 1 1 {name=M76
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 60 -1510 3 0 {name=M78
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 170 -1510 1 1 {name=M79
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 240 -1510 3 0 {name=M80
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -20 -1110 1 0 {name=M81
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 50 -1110 3 1 {name=M82
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 170 -1110 1 0 {name=M83
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 240 -1110 3 1 {name=M84
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 320 -1510 1 1 {name=M87
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 320 -1110 1 0 {name=M88
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -100 -1510 3 0 {name=M91
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -100 -1110 3 1 {name=M92
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -290 -1110 1 0 {name=M97
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 590 -1110 3 1 {name=M98
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -180 -1510 1 1 {name=M99
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 490 -1510 3 0 {name=M100
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -340 -1510 1 1 {name=M3
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 400 -1110 3 1 {name=M4
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -260 -1510 3 0 {name=M7
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 400 -1510 3 0 {name=M12
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 560 -1510 3 0 {name=M64
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -100 -1370 1 1 {name=M65
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 320 -1370 3 0 {name=M66
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -100 -1280 1 0 {name=M67
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 320 -1280 3 1 {name=M77
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -190 -1370 1 1 {name=M85
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -270 -1370 3 0 {name=M86
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -350 -1370 1 1 {name=M89
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 -1370 3 0 {name=M90
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 490 -1370 1 1 {name=M93
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 570 -1370 3 0 {name=M94
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -190 -1280 1 0 {name=M95
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -270 -1280 3 1 {name=M96
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -350 -1280 1 0 {name=M101
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 410 -1280 3 1 {name=M102
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 490 -1280 1 0 {name=M103
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 570 -1280 3 1 {name=M104
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -180 -1110 1 0 {name=M105
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -360 -1110 1 0 {name=M106
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 480 -1110 1 0 {name=M107
W=1
L=0.4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -400 -140 3 1 {name=M1
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -330 -140 1 0 {name=M2
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -260 -140 3 1 {name=M108
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -190 -140 1 0 {name=M109
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -120 -140 3 1 {name=M110
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -50 -140 1 0 {name=M111
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 20 -140 3 1 {name=M112
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 90 -140 1 0 {name=M113
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -400 80 3 0 {name=M114
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -330 80 1 1 {name=M115
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -260 80 3 0 {name=M116
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -190 80 1 1 {name=M117
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -120 80 3 0 {name=M118
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -50 80 1 1 {name=M119
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 20 80 3 0 {name=M120
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 90 80 1 1 {name=M121
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -380 -420 3 1 {name=M126
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -310 -420 1 0 {name=M127
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -240 -420 3 1 {name=M128
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -170 -420 1 0 {name=M129
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -100 -420 3 1 {name=M130
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -30 -420 1 0 {name=M131
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 40 -420 3 1 {name=M132
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 110 -420 1 0 {name=M133
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_wire.sym} -70 -400 2 0 {name=p2 sig_type=std_logic lab=VSS}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -440 340 3 1 {name=M134
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -370 340 1 0 {name=M135
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -300 340 3 1 {name=M136
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -230 340 1 0 {name=M137
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -160 340 3 1 {name=M138
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -90 340 1 0 {name=M139
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -20 340 3 1 {name=M140
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 50 340 1 0 {name=M141
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_wire.sym} -130 360 2 0 {name=p15 sig_type=std_logic lab=VSS}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -470 -420 3 1 {name=M142
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 190 -420 1 0 {name=M143
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -520 340 3 1 {name=M144
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 140 340 1 0 {name=M145
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/res_xhigh_po_1p41.sym} -180 -660 0 0 {name=R1
L=14
model=res_xhigh_po_1p41
spiceprefix=X
mult=1}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -480 -140 1 0 {name=M122
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -640 -140 1 0 {name=M123
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -480 80 1 1 {name=M124
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -640 80 1 1 {name=M125
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_wire.sym} -640 30 0 1 {name=p16 sig_type=std_logic lab=VSS}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 170 -140 3 1 {name=M146
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 170 80 3 0 {name=M147
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 350 -140 3 1 {name=M148
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_wire.sym} 380 -80 0 1 {name=p17 sig_type=std_logic lab=VSS}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 420 80 3 0 {name=M149
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {lab_wire.sym} 470 30 0 1 {name=p19 sig_type=std_logic lab=VSS}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -10 1060 1 0 {name=M150
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -600 -430 3 1 {name=M151
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 270 -420 1 0 {name=M152
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -600 340 3 1 {name=M153
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 210 340 1 0 {name=M154
W=7
L=1
nf=1
mult=1
ad="expr('int((@nf + 1)/2) * @W / @nf * 0.29')"
pd="expr('2*int((@nf + 1)/2) * (@W / @nf + 0.29)')"
as="expr('int((@nf + 2)/2) * @W / @nf * 0.29')"
ps="expr('2*int((@nf + 2)/2) * (@W / @nf + 0.29)')"
nrd="expr('0.29 / @W ')" nrs="expr('0.29 / @W ')"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
